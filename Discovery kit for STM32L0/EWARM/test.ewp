# IAR project test.ewp, settings and files
configuration test (ARM, debug)
  General.OGChipSelectEditMenu: STM32L053C8 ST STM32L053C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L053xx; USE_STM32L0538_DISCO
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32L0xx_HAL_Driver/Inc; ../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L0xx/Include; ../Drivers/CMSIS/Include; ../Drivers/BSP; ../Drivers/BSP/Components; ../Drivers/BSP/Components/Common; ../Drivers/BSP/STM32L0538-Discovery; ../Drivers/RF24; ../Drivers/ESP8266_LIBRARY
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: test.out
  ILINK.IlinkIcfFile: stm32l053xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/iar/: startup_stm32l053xx.s
  group Application/User
    ../Src/: bsp.c main.cpp stm32l0xx_hal_msp.c stm32l0xx_it.c utility.cpp
    ../Inc/: bsp.h main.h stm32l0xx_hal_conf.h stm32l0xx_it.h
  group Drivers/BSP/Compnents
    ../Drivers/BSP/Components/gde021a1/: gde021a1.c gde021a1.h
  group Drivers/BSP/STM32L0538-Discovery
    ../Drivers/BSP/STM32L0538-Discovery/: stm32l0538_discovery.c stm32l0538_discovery.h stm32l0538_discovery_epd.c stm32l0538_discovery_epd.h
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/: system_stm32l0xx.c
  group Drivers/ESP8266_LIBRARY
    ../Drivers/ESP8266_LIBRARY/: esp8266.cpp esp8266.h esp8266_ll.c esp8266_ll.h
  group Drivers/RF24
    ../Drivers/RF24/: nRF24L01.h printf.h RF24.cpp RF24.h RF24_config.h spiRF24.c spiRF24.h
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_usart.c
